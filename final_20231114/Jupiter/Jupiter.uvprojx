# Keil uVision project Jupiter.uvprojx, settings and files
target Jupiter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: Jupiter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __DCACHE_PRESENT
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\User\Inc;.\MidDriver\INC;..\Library\CMSIS\Include;..\Library\Device\SkyRelay\SKY32B750\Include;..\Library\StdDriver\Include;..\Library\StdDriver\Include\Can;.\App\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  group Application/MDK-ARM
    ../Library/Device/SkyRelay/SKY32B750/Source/ARM/: startup_SKY32B750.s
  group Application/CMSIS
    ../Library/Device/SkyRelay/SKY32B750/Source/: system_SKY32B750.c
  group Application/Driver
    ../Library/StdDriver/Source/: delay.c gpio.c mpu.c pinmux.c usci.c dma.c wdt.c fadc.c efc.c
  group Application/MidDriver
    ./MidDriver/: SPI_Driver.c GPIO_Driver.c USART_Driver.c Delay_Driver.c MPU_Driver.c IRQ_Handler.c DMA_Driver.c ADC_Driver.c SysClk_Driver.c WDT_Driver.c OSPI_Driver.c
  group Application/User
    ./User/: main.c RF_SPI_Config.c BB_Config.c Usart_Protocol.c ParamConfig.c Led.c Product.c
  group Application/App
    ./App/: App_Func.c
